* C:\Users\suman\eSim-Workspace\ADC\ADC.cir

* EESchema Netlist Version 1.1 (Spice format) creation date: 03/10/22 22:46:30

* To exclude a component from the Spice Netlist add [Spice_Netlist_Enabled] user FIELD set to: N
* To reorder the component spice node sequence add [Spice_Node_Sequence] user FIELD and define sequence: 2,1,0

* Sheet Name: /
U4  Net-_U4-Pad1_ Net-_U4-Pad2_ Net-_U4-Pad3_ Net-_U4-Pad4_ Net-_U4-Pad5_ Net-_U4-Pad6_ Net-_U4-Pad7_ GND Net-_U3-Pad1_ Net-_U3-Pad2_ Net-_U3-Pad3_ Net-_U3-Pad4_ Net-_U3-Pad5_ Net-_U3-Pad6_ Net-_U3-Pad7_ Net-_U3-Pad8_ adc_bridge_8
U5  Net-_U3-Pad9_ Net-_U3-Pad10_ Net-_U3-Pad11_ Net-_R16-Pad1_ D1 D0 dac_bridge_3
R2  Net-_R1-Pad2_ Net-_R2-Pad2_ 1k
R3  Net-_R2-Pad2_ Net-_R3-Pad2_ 1k
R4  Net-_R3-Pad2_ Net-_R4-Pad2_ 1k
R5  Net-_R4-Pad2_ Net-_R5-Pad2_ 1k
R6  Net-_R5-Pad2_ Net-_R6-Pad2_ 1k
R7  Net-_R6-Pad2_ Net-_R7-Pad2_ 1k
R8  Net-_R7-Pad2_ GND 1k
v1  Vref GND DC
U1  Vref plot_v1
U2  Va plot_v1
U3  Net-_U3-Pad1_ Net-_U3-Pad2_ Net-_U3-Pad3_ Net-_U3-Pad4_ Net-_U3-Pad5_ Net-_U3-Pad6_ Net-_U3-Pad7_ Net-_U3-Pad8_ Net-_U3-Pad9_ Net-_U3-Pad10_ Net-_U3-Pad11_ ss_8to3_priority_encoder
X2  Net-_R10-Pad1_ Net-_R1-Pad2_ Va GND Net-_R10-Pad2_ Net-_U4-Pad1_ Net-_X1-Pad7_ ? lm_741
X4  Net-_R12-Pad1_ Net-_R3-Pad2_ Va GND Net-_R12-Pad2_ Net-_U4-Pad3_ Net-_X1-Pad7_ ? lm_741
X5  Net-_R13-Pad1_ Net-_R4-Pad2_ Va GND Net-_R13-Pad2_ Net-_U4-Pad4_ Net-_X1-Pad7_ ? lm_741
X7  Net-_R15-Pad1_ Net-_R6-Pad2_ Va GND Net-_R15-Pad2_ Net-_U4-Pad6_ Net-_X1-Pad7_ ? lm_741
X6  Net-_R14-Pad1_ Net-_R5-Pad2_ Va GND Net-_R14-Pad2_ Net-_U4-Pad5_ Net-_X1-Pad7_ ? lm_741
X1  Net-_R9-Pad1_ Net-_R7-Pad2_ Va GND Net-_R9-Pad2_ Net-_U4-Pad7_ Net-_X1-Pad7_ ? lm_741
X3  Net-_R11-Pad1_ Net-_R2-Pad2_ Va GND Net-_R11-Pad2_ Net-_U4-Pad2_ Net-_X1-Pad7_ ? lm_741
R9  Net-_R9-Pad1_ Net-_R9-Pad2_ 1k
R15  Net-_R15-Pad1_ Net-_R15-Pad2_ 1k
R14  Net-_R14-Pad1_ Net-_R14-Pad2_ 1k
R13  Net-_R13-Pad1_ Net-_R13-Pad2_ 1k
R12  Net-_R12-Pad1_ Net-_R12-Pad2_ 1k
R11  Net-_R11-Pad1_ Net-_R11-Pad2_ 1k
R10  Net-_R10-Pad1_ Net-_R10-Pad2_ 1k
R16  Net-_R16-Pad1_ D2 1k
C1  D2 GND 1u
U6  D2 plot_v1
U7  D1 plot_v1
U8  D0 plot_v1
R1  Vref Net-_R1-Pad2_ 1k
v3  Net-_X1-Pad7_ GND DC
v2  Va GND DC

.end
